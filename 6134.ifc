Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-24T22:59:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 24 22:59:24 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{7DE328BC-D682-4B97-98A4-A1F90BAE7851}\ifc * Database version: 5507 * Database creation date: Fri Aug 24 22:59:23 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 24 22:59:24 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 24 22:59:24 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6134 Washbasin faucet, 230/12 V, 6134:6134 Washbasin faucet, 230/12 V:372631
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 16 mm; NominalDepth: 163 mm; NominalHeight: 205 mm; NominalWidth: 51 mm; Projection: 120 mm
Type - Electrical(Type) - Electrical Connection: 230 / 12 VAC; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6134; ConvergoRefNr: 0087-1809-0127-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 23/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150027260; EMC Directive: 89/336/EEC; EN Standard: EN 15091; LVI Number: 6116220; Noise Class: I (ISO 3822); Protection Class: IP 67 / transformer IP 40; RSK Number: 8553428; STF Certificate: STF VTT-RTH-00112-11; VVS Number: 704277104
Type - Identity Data(Type) - Class: Touchless, plug transformer; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;SWE;DNK;POL;RUS;LTU;UKR;EST;LVA; Model: 6134 Washbasin faucet, 230/12 V; Name_en: 6134 Washbasin faucet, 230/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6134; Product Datasheet: https://www.oras.com/datasheet/6134/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6134; Type Name: 6134 Washbasin faucet, 230/12 V; Usage Group: Offices, personnel sanitary facilities;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Afterflow Period: 1; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00388461 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110313_PDM_945851_5_(945851-05-14).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Max Flow Period: 120; Pressure Loss With Flow 01ls: 170000 Pa; Recognition Range: 0 - 40 cm; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6134/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, public & semi-public, health & Care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6134; Features: Touchless, plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6134; Name: 6134 Washbasin faucet, 230/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: 50x165x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6134; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6134 Washbasin faucet, 230/12 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.054093 m2; Volume: 0.00171623 m3
Identity Data - Mark: 28
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6134: 6134 Washbasin faucet, 230/12 V; Family and Type: 6134: 6134 Washbasin faucet, 230/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6134: 6134 Washbasin faucet, 230/12 V; Type Id: 6134: 6134 Washbasin faucet, 230/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
